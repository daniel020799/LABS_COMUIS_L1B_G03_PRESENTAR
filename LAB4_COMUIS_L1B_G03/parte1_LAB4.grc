options:
  parameters:
    author: G03
    copyright: UIS
    description: segunda parte del primer inciso
    generate_options: qt_gui
    id: parte1b
    output_language: python
    title: Modulacion PM ejercicio
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '1e-6'
    stop: '3'
    value: '2.8'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud Mensaje
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '1'
  states: {state: disabled}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '1'
  states: {}
- name: Kp
  id: variable_qtgui_range
  parameters:
    label: Coeficiene Kp
    start: '0'
    step: '1e-6'
    stop: '10'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: 50e6
    step: 1e6
    stop: 2e9
    value: 50e6
  states: {state: disabled}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: 50e6
    step: 1e6
    stop: 2e9
    value: 50e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia mensaje
    start: 1e3
    step: '100'
    stop: 20e3
    value: 1e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12.5e6
  states: {}
- name: Practica4Parte1_0
  id: Practica4Parte1
  parameters:
    Ac: Am
    Kp: Kp
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '0'
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Practica4Parte1_0, '0', qtgui_freq_sink_x_0, '0']
- [Practica4Parte1_0, '0', qtgui_time_sink_x_0, '0']
- [Practica4Parte1_0, '0', uhd_usrp_sink_0, '0']
- [Practica4Parte1_0, '0', uhd_usrp_sink_1, '0']
- [analog_sig_source_x_0, '0', Practica4Parte1_0, '0']

metadata:
  file_format: 1
