options:
  parameters:
    author: G03
    copyright: UIS
    description: Segunda parte primer inciso
    generate_options: qt_gui
    id: Practica4Parte2
    output_language: python
    title: Demodulador FM
  states: {}

blocks:
- name: Ga
  id: variable_qtgui_range
  parameters:
    label: Amplitud audio
    start: '0'
    step: '100e-3'
    stop: '3'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de portadora
    start: 88e6
    step: 100e3
    stop: 108e6
    value: 881e5
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: 200e3
    tau: '75e-6'
  states: {state: disabled}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: 200e3
  states: {state: disabled}
- name: analog_wfm_rcv_1
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: 200e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {state: disabled}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: 200e3
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: 200e3
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 881e5
    fc: fc
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 200e3
    fc: '0'
    fftsize: '8192'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate/50
    fc: '0'
    fftsize: 1024*8
    freqhalf: 'False'
    grid: 'True'
    type: float
    ymax: '-20'
    ymin: '-100'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '1'
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '200000'
    interp: '44100'
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_3
  id: rational_resampler_xxx
  parameters:
    decim: '200000'
    interp: '44100'
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc
    gain0: '0'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_fm_preemph_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_wfm_rcv_0, '0', analog_fm_preemph_0, '0']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_wfm_rcv_1, '0', blocks_multiply_const_vxx_1, '0']
- [analog_wfm_rcv_1, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_1, '0']
- [blocks_multiply_const_vxx_1, '0', rational_resampler_xxx_3, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_1, '0', analog_wfm_rcv_1, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_1, '0', audio_sink_0, '0']
- [rational_resampler_xxx_2, '0', low_pass_filter_1, '0']
- [rational_resampler_xxx_3, '0', audio_sink_1, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_2, '0']

metadata:
  file_format: 1
